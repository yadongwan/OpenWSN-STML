# IAR project Project.ewp, settings and files
configuration STM32L476RG_NUCLEO (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L476xx; USE_STM32L4XX_NUCLEO; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: ..\Inc; E:\openwsn\openwsn-fw\bsp\boards\openmotestmL4\CMSIS\Device\ST\STM32L4xx\Include; E:\openwsn\openwsn-fw\bsp\boards\openmotestmL4\library\inc; E:\openwsn\openwsn-fw\bsp\boards\openmotestmL4\CMSIS\Include; E:\openwsn\openwsn-fw\bsp\boards; E:\openwsn\openwsn-fw\bsp\boards\openmotestmL4; E:\openwsn\openwsn-fw\drivers\common; E:\openwsn\openwsn-fw\inc; E:\openwsn\openwsn-fw\kernel; E:\openwsn\openwsn-fw\openstack; E:\openwsn\openwsn-fw\bsp\chips\at86rf233; E:\openwsn\openwsn-fw\bsp\chips; E:\openwsn\openwsn-fw\openstack; E:\openwsn\openwsn-fw\openstack\02a-MAClow; E:\openwsn\openwsn-fw\openstack\02b-MAChigh; E:\openwsn\openwsn-fw\openstack\03a-IPHC; E:\openwsn\openwsn-fw\openstack\03b-IPv6; E:\openwsn\openwsn-fw\openstack\04-TRAN; E:\openwsn\openwsn-fw\openstack\cross-layers; E:\openwsn\openwsn-fw\openapps; E:\openwsn\openwsn-fw\openapps\c6t; E:\openwsn\openwsn-fw\openapps\cinfo; E:\openwsn\openwsn-fw\openapps\cleds; E:\openwsn\openwsn-fw\openapps\cstorm; E:\openwsn\openwsn-fw\openapps\cwellknown; E:\openwsn\openwsn-fw\openapps\rrt; E:\openwsn\openwsn-fw\openapps\techo; E:\openwsn\openwsn-fw\openapps\tohlone; E:\openwsn\openwsn-fw\openapps\uecho
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32L476RG-Nucleo.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../../common/03oos_openwsn/: 03oos_openwsn.c 03oos_openwsn.h
  group BSP/Boards/OpenMoteSTML
    ../../../../bsp/boards/openmotestmL4/: board.c board_info.h bsp_timer.c debugpins.c eui64.c gpio.c leds.c nvic.c radiotimer.c rcc.c spi.c uart.c
  group BSP/Boards/OpenMoteSTML/Configure
    ../../../../bsp/boards/openmotestmL4/configure/: stm32_assert.h stm32l4xx_it.c stm32l4xx_it.h system_stm32l4xx.c
  group BSP/Boards/OpenMoteSTML/EWARM
    ../../../../bsp/boards/openmotestmL4/ewarm/: startup_stm32l476xx.s
  group BSP/Boards/OpenMoteSTML/Lib
    ../../../../bsp/boards/openmotestmL4/library/inc/: stm32_assert_template.h stm32l4xx_ll_adc.h stm32l4xx_ll_bus.h stm32l4xx_ll_comp.h stm32l4xx_ll_cortex.h stm32l4xx_ll_crc.h stm32l4xx_ll_crs.h stm32l4xx_ll_dac.h stm32l4xx_ll_dma.h stm32l4xx_ll_dma2d.h stm32l4xx_ll_dmamux.h stm32l4xx_ll_exti.h stm32l4xx_ll_fmc.h stm32l4xx_ll_gpio.h stm32l4xx_ll_i2c.h stm32l4xx_ll_iwdg.h stm32l4xx_ll_lib.h stm32l4xx_ll_lptim.h stm32l4xx_ll_lpuart.h stm32l4xx_ll_opamp.h stm32l4xx_ll_pwr.h stm32l4xx_ll_rcc.h stm32l4xx_ll_rng.h stm32l4xx_ll_rtc.h stm32l4xx_ll_sdmmc.h stm32l4xx_ll_spi.h stm32l4xx_ll_swpmi.h stm32l4xx_ll_system.h stm32l4xx_ll_tim.h stm32l4xx_ll_usart.h stm32l4xx_ll_utils.h stm32l4xx_ll_wwdg.h
    ../../../../bsp/boards/openmotestmL4/library/src/: stm32l4xx_ll_adc.c stm32l4xx_ll_comp.c stm32l4xx_ll_crc.c stm32l4xx_ll_crs.c stm32l4xx_ll_dac.c stm32l4xx_ll_dma.c stm32l4xx_ll_dma2d.c stm32l4xx_ll_exti.c stm32l4xx_ll_gpio.c stm32l4xx_ll_i2c.c stm32l4xx_ll_lptim.c stm32l4xx_ll_lpuart.c stm32l4xx_ll_opamp.c stm32l4xx_ll_pwr.c stm32l4xx_ll_rcc.c stm32l4xx_ll_rng.c stm32l4xx_ll_rtc.c stm32l4xx_ll_spi.c stm32l4xx_ll_swpmi.c stm32l4xx_ll_tim.c stm32l4xx_ll_usart.c stm32l4xx_ll_utils.c
  group BSP/Chips/At86rf231
    ../../../../bsp/chips/at86rf233/: at86rf233.h radio.c
  group BSP/Drivers/Common
    ../../../../drivers/common/: openhdlc.c openhdlc.h openserial.c openserial.h opentimers.c opentimers.h
  group Doc
    ../: readme.txt
  group Inc
    ../../../../inc/: opendefs.h
  group Kernel
    ../../../../kernel/openos/: scheduler.c
    ../../../../kernel/: scheduler.h
  group Openapps
    ../../../../openapps/: openapps.c
  group Openapps/c6t
    ../../../../openapps/c6t/: c6t.c c6t.h
  group Openapps/cinfo
    ../../../../openapps/cinfo/: cinfo.c cinfo.h
  group Openapps/cleds
    ../../../../openapps/cleds/: cleds.c cleds.h
  group Openapps/cstorm
    ../../../../openapps/cstorm/: cstorm.c cstorm.h
  group Openapps/cwellknow
    ../../../../openapps/cwellknown/: cwellknown.c cwellknown.h
  group Openapps/rrt
    ../../../../openapps/rrt/: rrt.c rrt.h
  group Openapps/techo
    ../../../../openapps/techo/: techo.c techo.h
  group Openapps/tohlone
    ../../../../openapps/tohlone/: tohlone.c tohlone.h tohlone_webpages.c tohlone_webpages.h
  group Openapps/uecho
    ../../../../openapps/uecho/: uecho.c uecho.h
  group Openstack
    ../../../../openstack/: openstack.c openstack.h
  group Openstack/02a-MAClow
    ../../../../openstack/02a-MAClow/: adaptive_sync.c adaptive_sync.h IEEE802154.c IEEE802154.h IEEE802154E.c IEEE802154E.h topology.c topology.h
  group Openstack/02b-MAChigh
    ../../../../openstack/02b-MAChigh/: neighbors.c neighbors.h otf.c otf.h processIE.c processIE.h schedule.c schedule.h sixtop.c sixtop.h
  group Openstack/03a-IPHC
    ../../../../openstack/03a-IPHC/: iphc.c iphc.h openbridge.c openbridge.h
  group Openstack/03b-IPV6
    ../../../../openstack/03b-IPv6/: forwarding.c forwarding.h icmpv6.c icmpv6.h icmpv6echo.c icmpv6echo.h icmpv6rpl.c icmpv6rpl.h
  group Openstack/04-TRAN
    ../../../../openstack/04-TRAN/: opencoap.c opencoap.h opentcp.c opentcp.h openudp.c openudp.h
  group Openstack/cross-layers
    ../../../../openstack/cross-layers/: idmanager.c idmanager.h openqueue.c openqueue.h openrandom.c openrandom.h packetfunctions.c packetfunctions.h
